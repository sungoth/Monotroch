# Keil uVision project Monotroch.uvprojx, settings and files
target Monotroch Configuration (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Monotroch Configuration
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,MPU6050,CFG_DBG_PRINT,CFG_STD_PRINTF,ARM_MATH_CM7,__FPU_PRESENT
  c misc: --C99
  c include: ..\Inc;     D:\STM32Cube\Repository\STM32Cube_FW_F7_V1.1.0\Drivers\STM32F7xx_HAL_Driver\Inc;     D:\STM32Cube\Repository\STM32Cube_FW_F7_V1.1.0\Drivers\STM32F7xx_HAL_Driver\Inc\Legacy;     D:\STM32Cube\Repository\STM32Cube_FW_F7_V1.1.0\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM7\r0p1;     D:\STM32Cube\Repository\STM32Cube_FW_F7_V1.1.0\Middlewares\Third_Party\FreeRTOS\Source\include;     D:\STM32Cube\Repository\STM32Cube_FW_F7_V1.1.0\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;     D:\STM32Cube\Repository\STM32Cube_FW_F7_V1.1.0\Drivers\CMSIS\Include;     D:\STM32Cube\Repository\STM32Cube_FW_F7_V1.1.0\Drivers\CMSIS\Device\ST\STM32F7xx\Include;     ..\Drv\eMPL
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: i2c.c tim.c usart.c main.c freertos.c stm32f7xx_it.c gpio.c stm32f7xx_hal_msp.c retarget.c mpu.c up_computer.c control.c
  group Middlewares/FreeRTOS
    D:/STM32Cube/Repository/STM32Cube_FW_F7_V1.1.0/Middlewares/Third_Party/FreeRTOS/Source/: queue.c croutine.c timers.c event_groups.c list.c tasks.c
    D:/STM32Cube/Repository/STM32Cube_FW_F7_V1.1.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    D:/STM32Cube/Repository/STM32Cube_FW_F7_V1.1.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    D:/STM32Cube/Repository/STM32Cube_FW_F7_V1.1.0/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Drivers/STM32F7xx_HAL_Driver
    D:/STM32Cube/Repository/STM32Cube_FW_F7_V1.1.0/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_pwr.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_uart.c stm32f7xx_hal_i2c.c stm32f7xx_hal_rcc.c stm32f7xx_hal_cortex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc_ex.c
  group Application/MDK-ARM
    D:/STM32Cube/Repository/STM32Cube_FW_F7_V1.1.0/Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/arm/: startup_stm32f746xx.s
  group Drivers/CMSIS
    D:/STM32Cube/Repository/STM32Cube_FW_F7_V1.1.0/Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Drivers/MPU6050
    ../Drv/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
